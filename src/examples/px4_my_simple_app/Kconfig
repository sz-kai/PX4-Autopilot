## src/examples/px4_my_simple_app/Kconfig
```kconfig
menuconfig EXAMPLES_PX4_MY_SIMPLE_APP
	bool "我的超级无敌无人机程序"
	default n
	---help---
		Enable support for px4_my_simple_app
```
